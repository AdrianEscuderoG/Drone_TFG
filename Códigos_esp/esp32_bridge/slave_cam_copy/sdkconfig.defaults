## Códigos_esp/esp32_bridge/slave_cam_copy/sdkconfig.defaults
```kconfig
# sdkconfig.defaults
CONFIG_SPIRAM=y
CONFIG_SPIRAM_MODE_OCT=y
CONFIG_SPIRAM_SPEED_80M=y
CONFIG_ESP32S3_SPIRAM_SUPPORT=y
```
